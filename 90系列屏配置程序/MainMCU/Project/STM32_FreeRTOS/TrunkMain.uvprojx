# Keil uVision project TrunkMain.uvprojx, settings and files
target DS92_Debug (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: APM32E103VE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SP50Pro_Debug +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL,STM32F10X_HD,EN_S7_SMART,DEBUG,APM32E103
  c include: .\Config;.\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F10x\Include;.\Utilities\STM32_EVAL;.\Utilities\STM32_EVAL\Common;.\Utilities\STM32_EVAL\STM3210E_EVAL;.\Utilities\Third_Party\fat_fs\inc;.\Libraries\STemWinLibrary522\inc;.\Libraries\STemWinLibrary522\Config;.\Utilities\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\Utilities\Third_Party\FreeRTOS\Source\include;.\Libraries\CMSIS\Include;..\..\Appication;..\..\Domain;..\..\GUI;..\..\HAL;..\..\Resources;..\..\Utilities;..\..\Driver;..\STM32_FreeRTOS;..\..\System
  asm include: .\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./User/: main.c
    ../../Appication/: HomeView.c
    ../../: 80SystemInfo.c
  group Driver
    ../../Driver/: bsp_timer.c bsp_touch.c ENTimer.c Driver_SSD2828.c LCD_RA8889.c RA8889.c RA8889_API.c GT911_i2c.c
  group Config
    ./Config/: GUIConf_stm3210e_eval.c LCDConf_stm3210e_eval.c GUI_X_Touch_Analog.c GUIDRV_Template.c system_stm32f10x.c startup_stm32f10x_hd_mdkarm.s
  group STemWin522
    ./Libraries/STemWinLibrary522/Lib/: STemWin522_CM3_OS_Keil.lib
    ./Libraries/STemWinLibrary522/OS/: GUI_X_FreeRTOS.c
    ./Libraries/STemWinLibrary522/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Generic.h GUIDRV_Lin.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group ThirdParty
    ./Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ./Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port_cm3.c
    ./Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group ST_FwLibrary
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c stm3210e_eval_fsmc_sram.c stm3210e_eval_spi_flash.c
